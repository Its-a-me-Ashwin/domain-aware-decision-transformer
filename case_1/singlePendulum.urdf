Commit message: Single pendulium added

File: case_1/singlePendulum.urdf (robot description, URDF)
Before this commit: robot single_inverted_pendulum, 3 links, 2 joints
Joints:
- joint cart_slide_joint: limit lower=-5.0 upper=5.0 effort=100.0 velocity=1.0 -> effort=100.0 velocity=1.0
